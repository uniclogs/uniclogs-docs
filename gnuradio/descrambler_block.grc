options:
  parameters:
    author: ryan
    category: '[UniClOGS]'
    copyright: PSAS
    generate_options: hb
    id: descrambler
    output_language: python
    title: Descrambler
  states: {}

blocks:
- name: length
  id: variable
  parameters:
    value: '16'
  states: {}
- name: mask
  id: variable
  parameters:
    value: '0x21'
  states: {}
- name: path_select
  id: variable
  parameters:
    value: '0'
  states: {}
- name: seed
  id: variable
  parameters:
    value: '0'
  states: {}
- name: blocks_selector_1
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: path_select
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: byte
  states: {}
- name: digital_descrambler_bb_0
  id: digital_descrambler_bb
  parameters:
    len: length
    mask: mask
    seed: seed
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: byte
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: byte
  states: {}

connections:
- [blocks_selector_1, '0', pad_sink_0, '0']
- [digital_descrambler_bb_0, '0', blocks_selector_1, '1']
- [pad_source_0, '0', blocks_selector_1, '0']
- [pad_source_0, '0', digital_descrambler_bb_0, '0']

metadata:
  file_format: 1
