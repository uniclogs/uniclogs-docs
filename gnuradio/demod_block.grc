options:
  parameters:
    author: Miles Simpson
    category: '[UniClOGS]'
    copyright: Portland State Aerospace Society
    generate_options: hb
    id: demod_block
    output_language: python
    title: Demodulation
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_am_demod_cf_0
  id: analog_am_demod_cf
  parameters:
    audio_pass: '5000'
    audio_stop: '5500'
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_pass: '15000'
    audio_stop: '16000'
    deviation: '75000'
    gain: '1.0'
    tau: '75e-6'
  states: {}
- name: audio_path_select
  id: parameter
  parameters:
    label: Audio Demodulation Select
    type: intx
    value: '1'
  states: {}
- name: blocks_selector_1
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: data_path_select
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: byte
  states: {}
- name: blocks_selector_1_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: audio_path_select
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: data_path_select
  id: parameter
  parameters:
    label: Data Demodulation Select
    type: intx
    value: '1'
  states: {}
- name: digital_gfsk_demod_0
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '2'
    sensitivity: '1.0'
  states: {}
- name: digital_gmsk_demod_0
  id: digital_gmsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '2'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: data_out
    type: byte
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: audio_out
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}

connections:
- [analog_am_demod_cf_0, '0', blocks_selector_1_0, '0']
- [analog_fm_demod_cf_0, '0', blocks_selector_1_0, '1']
- [blocks_selector_1, '0', pad_sink_0, '0']
- [blocks_selector_1_0, '0', pad_sink_1, '0']
- [digital_gfsk_demod_0, '0', blocks_selector_1, '0']
- [digital_gmsk_demod_0, '0', blocks_selector_1, '1']
- [pad_source_0, '0', analog_am_demod_cf_0, '0']
- [pad_source_0, '0', analog_fm_demod_cf_0, '0']
- [pad_source_0, '0', digital_gfsk_demod_0, '0']
- [pad_source_0, '0', digital_gmsk_demod_0, '0']

metadata:
  file_format: 1
