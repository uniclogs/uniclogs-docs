options:
  parameters:
    author: Miles Simpson
    category: '[UniClOGS]'
    copyright: Portland State Aerospace Society
    generate_options: hb
    id: demod_block
    output_language: python
    title: Demodulation
  states: {}

blocks:
- name: audio_path_select
  id: variable
  parameters:
    value: '0'
  states: {}
- name: data_path_select
  id: variable
  parameters:
    value: '0'
  states: {}
- name: samp_per_sym
  id: variable
  parameters:
    value: '5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_am_demod_cf_0
  id: analog_am_demod_cf
  parameters:
    audio_pass: '5000'
    audio_stop: '5500'
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_pass: '15000'
    audio_stop: '16000'
    deviation: '75000'
    gain: '1.0'
    tau: '75e-6'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi*500)
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_selector_1
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: data_path_select
    num_inputs: '4'
    num_outputs: '1'
    output_index: '0'
    type: byte
  states: {}
- name: blocks_selector_1_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: audio_path_select
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.175'
    gain_omega: 0.25*0.175*0.175
    mu: '0.5'
    omega: samp_per_sym*(1+0.0)
    omega_relative_limit: '0.005'
    type: float
  states: {}
- name: digital_clock_recovery_mm_xx_0_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.175'
    gain_omega: 0.25*0.175*0.175
    mu: '0.5'
    omega: samp_per_sym*(1+0.0)
    omega_relative_limit: '0.005'
    type: float
  states: {}
- name: digital_gfsk_demod_0
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '2'
    sensitivity: '1.0'
  states: {}
- name: digital_gmsk_demod_0
  id: digital_gmsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '2'
  states: {}
- name: note_0
  id: note
  parameters:
    note: FSK
  states: {}
- name: note_1
  id: note
  parameters:
    note: AFSK
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: data_out
    type: byte
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: audio_out
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}

connections:
- [analog_am_demod_cf_0, '0', blocks_selector_1_0, '0']
- [analog_fm_demod_cf_0, '0', blocks_selector_1_0, '1']
- [analog_quadrature_demod_cf_0, '0', digital_clock_recovery_mm_xx_0_0, '0']
- [blocks_complex_to_float_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [blocks_selector_1, '0', pad_sink_0, '0']
- [blocks_selector_1_0, '0', pad_sink_1, '0']
- [digital_binary_slicer_fb_0, '0', blocks_selector_1, '2']
- [digital_binary_slicer_fb_0_0, '0', blocks_selector_1, '3']
- [digital_clock_recovery_mm_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [digital_clock_recovery_mm_xx_0_0, '0', digital_binary_slicer_fb_0_0, '0']
- [digital_gfsk_demod_0, '0', blocks_selector_1, '0']
- [digital_gmsk_demod_0, '0', blocks_selector_1, '1']
- [pad_source_0, '0', analog_am_demod_cf_0, '0']
- [pad_source_0, '0', analog_fm_demod_cf_0, '0']
- [pad_source_0, '0', analog_quadrature_demod_cf_0, '0']
- [pad_source_0, '0', blocks_complex_to_float_0, '0']
- [pad_source_0, '0', digital_gfsk_demod_0, '0']
- [pad_source_0, '0', digital_gmsk_demod_0, '0']

metadata:
  file_format: 1
