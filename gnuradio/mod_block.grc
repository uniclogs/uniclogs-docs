options:
  parameters:
    author: Miles Simpson
    category: '[UniClOGS]'
    copyright: Portland State Aerospace Society
    generate_options: hb
    id: mod_block
    output_language: python
    title: Modulation
  states: {}

blocks:
- name: path_select
  id: variable
  parameters:
    value: '0'
  states: {}
- name: samp_per_sym
  id: variable
  parameters:
    value: '5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: '48000'
    fh: '-1.0'
    max_dev: 5e3
    quad_rate: '480000'
    tau: '75e-6'
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: '48000'
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: '480000'
    tau: '75e-6'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-0.5'
    type: float
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.5'
    type: float
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: samp_per_sym
    type: byte
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '3'
    output_index: path_select % 2
    type: byte
  states: {}
- name: blocks_selector_0_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: path_select % 2
    type: float
  states: {}
- name: blocks_selector_1
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: path_select
    num_inputs: '5'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.35'
    samples_per_symbol: '2'
    sensitivity: '1.0'
  states: {}
- name: digital_gmsk_mod_0
  id: digital_gmsk_mod
  parameters:
    bt: '0.35'
    samples_per_symbol: '2'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: data_in
    type: byte
  states: {}
- name: pad_source_0_0
  id: pad_source
  parameters:
    label: audio_in
    type: float
  states: {}

connections:
- [analog_nbfm_tx_0, '0', blocks_selector_1, '3']
- [analog_wfm_tx_0, '0', blocks_selector_1, '4']
- [blocks_add_const_vxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_char_to_float_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_float_to_complex_0, '0', blocks_selector_1, '2']
- [blocks_multiply_const_vxx_0, '0', blocks_float_to_complex_0, '0']
- [blocks_repeat_0, '0', blocks_char_to_float_0, '0']
- [blocks_selector_0, '0', digital_gfsk_mod_0, '0']
- [blocks_selector_0, '1', digital_gmsk_mod_0, '0']
- [blocks_selector_0, '2', blocks_repeat_0, '0']
- [blocks_selector_0_0, '0', analog_nbfm_tx_0, '0']
- [blocks_selector_0_0, '1', analog_wfm_tx_0, '0']
- [blocks_selector_1, '0', pad_sink_0, '0']
- [digital_gfsk_mod_0, '0', blocks_selector_1, '0']
- [digital_gmsk_mod_0, '0', blocks_selector_1, '1']
- [pad_source_0, '0', blocks_selector_0, '0']
- [pad_source_0_0, '0', blocks_selector_0_0, '0']

metadata:
  file_format: 1
