options:
  parameters:
    author: Ryan Medick
    category: '[UniClOGS]'
    copyright: Portland State Aerospace Society
    generate_options: hb
    id: FEC_enc_block
    output_language: python
    title: FEC Encoding
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_selector_1
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: path_select
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: byte
  states: {}
- name: fec_generic_encoder_0
  id: fec_generic_encoder
  parameters:
    encoder: encoder_variable
    itype: byte
    otype: byte
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: byte
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: byte
  states: {}
- name: path_select
  id: parameter
  parameters:
    label: FEC Encoding Selection
    type: intx
    value: '0'
  states: {}

connections:
- [blocks_selector_1, '0', pad_sink_0, '0']
- [fec_generic_encoder_0, '0', blocks_selector_1, '1']
- [pad_source_0, '0', blocks_selector_1, '0']
- [pad_source_0, '0', fec_generic_encoder_0, '0']

metadata:
  file_format: 1
