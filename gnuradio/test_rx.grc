options:
  parameters:
    author: ryan
    generate_options: no_gui
    id: test_rx
    output_language: python
    title: Test Rx
  states: {}

blocks:
- name: samp_per_sym
  id: variable
  parameters:
    value: '5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.175'
    gain_omega: 0.25*0.175*0.175
    mu: '0.5'
    omega: samp_per_sym*(1+0.0)
    omega_relative_limit: '0.005'
    type: float
  states: {}
- name: digital_descrambler_bb_0
  id: digital_descrambler_bb
  parameters:
    len: '16'
    mask: '0x21'
    seed: '0'
  states: {}
- name: limesdr_source_0
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    ch_align: 'False'
    channel_mode: '0'
    oversample: '0'
    rf_freq: 100e6
    samp_rate: samp_rate
  states: {}
- name: satellites_hdlc_deframer_0
  id: satellites_hdlc_deframer
  parameters:
    check_fcs: 'True'
    max_length: '10000'
  states: {}
- name: satellites_nrzi_decode_0
  id: satellites_nrzi_decode
  parameters: {}
  states: {}

connections:
- [blocks_complex_to_float_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [digital_binary_slicer_fb_0, '0', satellites_nrzi_decode_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [digital_descrambler_bb_0, '0', satellites_hdlc_deframer_0, '0']
- [limesdr_source_0, '0', blocks_complex_to_float_0, '0']
- [satellites_hdlc_deframer_0, out, blocks_message_debug_0, print_pdu]
- [satellites_nrzi_decode_0, '0', digital_descrambler_bb_0, '0']

metadata:
  file_format: 1
