options:
  parameters:
    author: Lime Microsystems
    category: Custom
    generate_options: qt_gui
    id: top_block
    output_language: python
    title: FM receiver
  states: {}

blocks:
- name: cut_freq
  id: variable_qtgui_range
  parameters:
    label: Cutoff Frequency
    orient: Qt.Horizontal
    start: '1000'
    step: '1000'
    stop: '1000000'
    value: '500000'
  states: {}
- name: trans_width
  id: variable_qtgui_range
  parameters:
    label: Tansistion Width
    orient: Qt.Horizontal
    start: '10000'
    step: '10000'
    stop: '500000'
    value: '100000'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    label: volume
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '10'
    value: '5'
  states: {}
- name: analog_wfm_rcv_0_1
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '10'
    quad_rate: 480e3
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: limesdr_source_0_0
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    calibr_bandw_ch0: '0'
    calibr_bandw_ch1: '0'
    channel_mode: '0'
    digital_bandw_ch0: 100e3
    digital_bandw_ch1: 100e3
    gain_dB_ch0: '60'
    gain_dB_ch1: '60'
    lna_path_ch1: '1'
    oversample: '0'
    rf_freq: 100.1e6
    samp_rate: 2e6
  states: {}
- name: low_pass_filter_0_1
  id: low_pass_filter
  parameters:
    cutoff_freq: cut_freq
    decim: '1'
    gain: '1'
    samp_rate: 2e6
    type: fir_filter_ccf
    width: trans_width
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: '2000000'
    fc: '100100000'
    fftsize: '1024'
    name: '"Low Pass Filter"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_1_0_1
  id: rational_resampler_xxx
  parameters:
    decim: '200'
    interp: '48'
    taps: ''
    type: ccc
  states: {}

connections:
- [analog_wfm_rcv_0_1, '0', blocks_multiply_const_vxx_0_1, '0']
- [blocks_multiply_const_vxx_0_1, '0', audio_sink_0_0, '0']
- [limesdr_source_0_0, '0', low_pass_filter_0_1, '0']
- [low_pass_filter_0_1, '0', qtgui_sink_x_0, '0']
- [low_pass_filter_0_1, '0', rational_resampler_xxx_1_0_1, '0']
- [rational_resampler_xxx_1_0_1, '0', analog_wfm_rcv_0_1, '0']

metadata:
  file_format: 1
