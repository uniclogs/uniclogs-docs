options:
  parameters:
    author: Miles Simpson
    category: '[UniClOGS]'
    copyright: Portland State Aerospace Society
    generate_options: hb
    id: deframing_block
    output_language: python
    title: 'Deframing '
  states: {}

blocks:
- name: path_select
  id: variable_config
  parameters:
    config_file: default
    option: key
    section: main
    type: real
    value: '0'
    writeback: None
  states: {}
- name: samp_rate
  id: variable_config
  parameters:
    config_file: default
    option: key
    section: framing
    type: real
    value: 32k
    writeback: None
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_selector_1
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: path_select
    num_inputs: '1'
    num_outputs: '2'
    output_index: '0'
    type: float
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: message
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: byte
  states: {}
- name: satellites_ax25_deframer_0
  id: satellites_ax25_deframer
  parameters:
    g3ruh_scrambler: 'True'
  states: {}
- name: satellites_ccsds_concatenated_deframer_0
  id: satellites_ccsds_concatenated_deframer
  parameters:
    differential: 'False'
    dual_basis: 'False'
    frame_size: '223'
    nasa_dsn: 'False'
    threshold: '0'
    use_scrambler: 'True'
  states: {}

connections:
- [blocks_char_to_float_0, '0', blocks_selector_1, '0']
- [blocks_selector_1, '0', satellites_ax25_deframer_0, '0']
- [blocks_selector_1, '1', satellites_ccsds_concatenated_deframer_0, '0']
- [pad_source_0, '0', blocks_char_to_float_0, '0']
- [satellites_ax25_deframer_0, out, pad_sink_0, in]
- [satellites_ccsds_concatenated_deframer_0, out, pad_sink_0, in]

metadata:
  file_format: 1
