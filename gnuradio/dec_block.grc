options:
  parameters:
    author: Miles Simpson
    category: '[UniClOGS]'
    copyright: Portland State Aerospace Society
    generate_options: hb
    id: dec_block
    output_language: python
    title: Decoding
  states: {}

blocks:
- name: path_select
  id: variable_config
  parameters:
    config_file: default
    option: key
    section: coding
    type: int
    value: '0'
    writeback: None
  states: {}
- name: blocks_selector_1
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: path_select
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: byte
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: byte
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: byte
  states: {}
- name: satellites_nrzi_decode_0_0
  id: satellites_nrzi_decode
  parameters: {}
  states: {}

connections:
- [blocks_selector_1, '0', pad_sink_0, '0']
- [pad_source_0, '0', blocks_selector_1, '0']
- [pad_source_0, '0', satellites_nrzi_decode_0_0, '0']
- [satellites_nrzi_decode_0_0, '0', blocks_selector_1, '1']

metadata:
  file_format: 1
