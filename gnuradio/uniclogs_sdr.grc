options:
  parameters:
    author: Miles Simpson
    category: '[UniClOGS]'
    copyright: Portland State Aerospace Society
    generate_options: no_gui
    id: uniclogs_sdr
    output_language: python
    realtime_scheduling: '1'
    title: SDR Interface
  states: {}

blocks:
- name: rx_analog_filter
  id: variable
  parameters:
    value: samp_rate
  states: {}
- name: rx_center_freq
  id: variable
  parameters:
    value: '[[436.5e6,145e6],[145e6,436.5e6]]'
  states: {}
- name: rx_digital_filter
  id: variable
  parameters:
    value: samp_rate - 500e3
  states: {}
- name: rx_nco_freq
  id: variable
  parameters:
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 4.8e6
  states: {}
- name: tx_analog_filter
  id: variable
  parameters:
    value: 5e6
  states: {}
- name: tx_center_freq
  id: variable
  parameters:
    value: '[[0,144.63e6,1265e6],[0,436e6,0]]'
  states: {}
- name: tx_digital_filter
  id: variable
  parameters:
    value: '0'
  states: {}
- name: tx_nco_freq
  id: variable
  parameters:
    value: '0'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '0'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: tx_src
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: channel
  id: parameter
  parameters:
    label: Channel Select
    short_id: c
    type: intx
    value: '0'
  states: {}
- name: limesdr_sink_0_0
  id: limesdr_sink
  parameters:
    allow_tcxo_dac: '0'
    analog_bandw_ch0: tx_analog_filter
    analog_bandw_ch1: tx_analog_filter
    calibr_bandw_ch0: samp_rate
    calibr_bandw_ch1: samp_rate
    channel_mode: '0'
    dacVal: '125'
    digital_bandw_ch0: tx_digital_filter
    digital_bandw_ch1: tx_digital_filter
    gain_dB_ch0: tx_gain
    gain_dB_ch1: tx_gain
    nco_freq_ch0: tx_nco_freq
    nco_freq_ch1: tx_nco_freq
    oversample: '0'
    pa_path_ch0: tx_band
    pa_path_ch1: tx_band
    rf_freq: tx_center_freq[channel][tx_band]
    samp_rate: samp_rate
  states: {}
- name: limesdr_source_0_0
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    analog_bandw_ch0: rx_analog_filter
    analog_bandw_ch1: rx_analog_filter
    calibr_bandw_ch0: samp_rate
    calibr_bandw_ch1: samp_rate
    ch_align: 'False'
    channel_mode: '0'
    dacVal: '125'
    digital_bandw_ch0: rx_digital_filter
    digital_bandw_ch1: rx_digital_filter
    gain_dB_ch0: rx_gain
    gain_dB_ch1: rx_gain
    lna_path_ch0: '2'
    nco_freq_ch0: rx_nco_freq
    nco_freq_ch1: rx_nco_freq
    oversample: '0'
    rf_freq: rx_center_freq[rx_swap][channel]
    samp_rate: samp_rate
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '10'
    taps: ''
    type: ccc
  states: {}
- name: rx_gain
  id: parameter
  parameters:
    label: RX Gain
    type: intx
    value: '55'
  states: {}
- name: rx_swap
  id: parameter
  parameters:
    label: RX Path Swap
    short_id: r
    type: intx
    value: '0'
  states: {}
- name: tx_band
  id: parameter
  parameters:
    label: TX Band Select
    short_id: b
    type: intx
    value: '1'
  states: {}
- name: tx_gain
  id: parameter
  parameters:
    label: TX Gain
    type: intx
    value: '25'
  states: {}
- name: tx_src
  id: parameter
  parameters:
    label: TX Source Select
    short_id: t
    type: intx
    value: '0'
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://0.0.0.0:8888
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_pull_source_0
  id: zeromq_pull_source
  parameters:
    address: tcp://uniclogs.psas.pdx.edu:8888
    timeout: '100'
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_selector_0, '1']
- [blocks_selector_0, '0', limesdr_sink_0_0, '0']
- [limesdr_source_0_0, '0', zeromq_pub_sink_0, '0']
- [rational_resampler_xxx_1, '0', blocks_selector_0, '0']
- [zeromq_pull_source_0, '0', rational_resampler_xxx_1, '0']

metadata:
  file_format: 1
