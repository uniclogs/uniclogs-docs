options:
  parameters:
    generate_options: qt_gui
    id: selector_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: cut_freq
  id: variable_qtgui_range
  parameters:
    label: Cutoff Frequency
    orient: Qt.Horizontal
    start: '1000'
    step: '1000'
    stop: '1000000'
    value: '500000'
  states: {}
- name: index
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '1'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: trans_width
  id: variable_qtgui_range
  parameters:
    label: Tansistion Width
    orient: Qt.Horizontal
    start: '10000'
    step: '10000'
    stop: '500000'
    value: '100000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '2'
    type: complex
  states: {}
- name: blocks_selector_0_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: index
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: limesdr_source_0_0
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    calibr_bandw_ch0: '0'
    calibr_bandw_ch1: '0'
    channel_mode: '0'
    digital_bandw_ch0: 100e3
    digital_bandw_ch1: 100e3
    gain_dB_ch0: '60'
    gain_dB_ch1: '60'
    lna_path_ch1: '1'
    oversample: '0'
    rf_freq: 100.1e6
    samp_rate: 2e6
  states: {}
- name: low_pass_filter_0_1
  id: low_pass_filter
  parameters:
    cutoff_freq: cut_freq
    decim: '1'
    gain: '1'
    samp_rate: 2e6
    type: fir_filter_ccf
    width: trans_width
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: '2000000'
    fc: '100100000'
    fftsize: '1024'
    name: '"Low Pass Filter"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [blocks_multiply_const_vxx_0, '0', blocks_selector_0_0, '1']
- [blocks_selector_0_0, '0', qtgui_sink_x_0, '0']
- [limesdr_source_0_0, '0', low_pass_filter_0_1, '0']
- [low_pass_filter_0_1, '0', blocks_multiply_const_vxx_0, '0']
- [low_pass_filter_0_1, '0', blocks_selector_0_0, '0']

metadata:
  file_format: 1
