options:
  parameters:
    copyright: PSAS
    generate_options: qt_gui
    id: uniclogs
    output_language: python
    title: UniClOGS
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: 100e6
    step: 10e6
    stop: 200e6
    value: 100e6
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: FEC_dec_block_0
  id: FEC_dec_block
  parameters:
    path_select: '0'
  states: {}
- name: FEC_enc_block_0
  id: FEC_enc_block
  parameters:
    path_select: '0'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_socket_pdu_0
  id: blocks_socket_pdu
  parameters:
    host: ''
    mtu: '10000'
    port: '52001'
    tcp_no_delay: 'False'
    type: TCP_SERVER
  states: {}
- name: dec_block_0
  id: dec_block
  parameters:
    path_select: '0'
  states: {}
- name: deframing_block_0
  id: deframing_block
  parameters:
    path_select: '0'
  states: {}
- name: demod_block_0
  id: demod_block
  parameters:
    audio_select: '0'
    data_select: '0'
  states: {}
- name: enc_block_0
  id: enc_block
  parameters:
    path_select: '0'
  states: {}
- name: framing_block_0
  id: framing_block
  parameters:
    path_select: '0'
  states: {}
- name: limesdr_sink_0
  id: limesdr_sink
  parameters:
    allow_tcxo_dac: '0'
    channel_mode: '0'
    oversample: '0'
    rf_freq: 100e6
    samp_rate: samp_rate
  states: {}
- name: limesdr_source_0
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    ch_align: 'False'
    channel_mode: '0'
    oversample: '0'
    rf_freq: freq
    samp_rate: samp_rate
  states: {}
- name: mod_block_0
  id: mod_block
  parameters:
    path_select: '0'
  states: {}

connections:
- [FEC_dec_block_0, '0', dec_block_0, '0']
- [FEC_enc_block_0, '0', mod_block_0, '0']
- [audio_source_0, '0', mod_block_0, '1']
- [blocks_socket_pdu_0, pdus, framing_block_0, in]
- [dec_block_0, '0', deframing_block_0, '0']
- [deframing_block_0, out, blocks_message_debug_0, print_pdu]
- [deframing_block_0, out, blocks_socket_pdu_0, pdus]
- [demod_block_0, '0', FEC_dec_block_0, '0']
- [demod_block_0, '1', audio_sink_0, '0']
- [enc_block_0, '0', FEC_enc_block_0, '0']
- [framing_block_0, '0', enc_block_0, '0']
- [limesdr_source_0, '0', demod_block_0, '0']
- [mod_block_0, '0', limesdr_sink_0, '0']

metadata:
  file_format: 1
