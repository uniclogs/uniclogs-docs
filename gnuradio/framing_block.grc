options:
  parameters:
    author: Miles Simpson
    category: '[UniClOGS]'
    copyright: Portland State Aerospace Society
    generate_options: hb
    id: framing_block
    output_language: python
    title: 'Framing '
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_pdu_to_tagged_stream_0_1
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_pdu_to_tagged_stream_0_1_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: path_select
    type: byte
  states: {}
- name: blocks_tagged_stream_to_pdu_0_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_tagged_stream_to_pdu_0_0_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: byte
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: message
  states: {}
- name: path_select
  id: parameter
  parameters:
    label: Framing Selection
    value: '0'
  states: {}
- name: satellites_hdlc_framer_0
  id: satellites_hdlc_framer
  parameters:
    postamble_bytes: '7'
    preamble_bytes: '50'
  states: {}
- name: satellites_hdlc_framer_0_0
  id: satellites_hdlc_framer
  parameters:
    postamble_bytes: '7'
    preamble_bytes: '50'
  states: {}

connections:
- [blocks_pdu_to_tagged_stream_0_1, '0', blocks_selector_0, '0']
- [blocks_pdu_to_tagged_stream_0_1_0, '0', pad_sink_0, '0']
- [blocks_selector_0, '0', blocks_tagged_stream_to_pdu_0_0, '0']
- [blocks_selector_0, '1', blocks_tagged_stream_to_pdu_0_0_0, '0']
- [blocks_tagged_stream_to_pdu_0_0, pdus, satellites_hdlc_framer_0, in]
- [blocks_tagged_stream_to_pdu_0_0_0, pdus, satellites_hdlc_framer_0_0, in]
- [pad_source_0, out, blocks_pdu_to_tagged_stream_0_1, pdus]
- [satellites_hdlc_framer_0, out, blocks_pdu_to_tagged_stream_0_1_0, pdus]
- [satellites_hdlc_framer_0_0, out, blocks_pdu_to_tagged_stream_0_1_0, pdus]

metadata:
  file_format: 1
