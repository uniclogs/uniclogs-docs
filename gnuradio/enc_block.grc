options:
  parameters:
    author: Miles Simpson
    category: '[UniClOGS]'
    copyright: Portland State Aerospace Society
    generate_options: hb
    id: enc_block
    output_language: python
    title: Encoding
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_selector_1
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: path_select
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: byte
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: byte
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: byte
  states: {}
- name: path_select
  id: parameter
  parameters:
    label: Encoding Selection
    value: '0'
  states: {}
- name: satellites_nrzi_encode_0
  id: satellites_nrzi_encode
  parameters: {}
  states: {}

connections:
- [blocks_selector_1, '0', pad_sink_0, '0']
- [pad_source_0, '0', blocks_selector_1, '0']
- [pad_source_0, '0', satellites_nrzi_encode_0, '0']
- [satellites_nrzi_encode_0, '0', blocks_selector_1, '1']

metadata:
  file_format: 1
